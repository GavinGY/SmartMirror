# Keil uVision project SpeechRecognition.uvproj, settings and files
target SpeechRecognition (MCS-51)
  device: STC11F60XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: SpeechRecognition +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SpeechRecognition;.\1_Application;.\2_System;.\3_BoardDrive;.\4_FirmwareLib;.\5_ChipDrive;.\7_ReadMe
  group System
    ./2_System/: config.h main.c interrupt.c
  group BoardDrive
    ./3_BoardDrive/: StdBsp.h LDChip.c Reg_RW.c
  group FirmwareLib
    ./4_FirmwareLib/: StdLib.h usart.c
  group ChipeDrive
    ./5_ChipDrive/: StdChip.h
  group ReadMe
    ./7_ReadMe/: ReadMe.txt
